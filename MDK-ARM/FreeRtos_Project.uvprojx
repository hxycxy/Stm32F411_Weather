# Keil uVision project FreeRtos_Project.uvprojx, settings and files
target FreeRtos_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: FreeRtos_Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/Drivers_my;../Drivers/Drivers_my/image;../Drivers/Drivers_my/dht11;../Drivers/Drivers_my/lcd;../Drivers/Drivers_my/timer;../Drivers/Drivers_my/esp32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/Driver_my/image
    ../Drivers/Drivers_my/image/: icon_duoyun.c icon_leizhenyu.c icon_na.c icon_qing.c icon_wenduji.c icon_wifi.c icon_yintian.c icon_yueliang.c icon_zhongxue.c icon_zhongyu.c img_error.c img_meihua.c img_wifi.c
  group Drivers/Driver_my/dht11
    ../Drivers/Drivers_my/dht11/: driver_dht11.c
  group Drivers/Driver_my/lcd
    ../Drivers/Drivers_my/lcd/: font16_maple.c font20_maple_bold.c font24_maple_bold.c font24_maple_semibold.c font32_maple_bold.c font54_maple_bold.c font54_maple_semibold.c font64_maple_extrabold.c font76_maple_extrabold.c fonts.c st7735.c
  group Drivers/Driver_my/timer
    ../Drivers/Drivers_my/timer/: driver_timer.c
  group Drivers/Driver_my/esp32
    ../Drivers/Drivers_my/esp32/: espAT.c
software components: CMSIS:CORE 4.3.0
